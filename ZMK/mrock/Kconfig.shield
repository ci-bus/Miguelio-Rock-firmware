## ZMK/mrock/Kconfig.shield
```kconfig
# Copyright (c) 2020 The ZMK Contributors
# SPDX-License-Identifier: MIT

config SHIELD_MROCK
	def_bool $(shields_list_contains,mrock)
```
